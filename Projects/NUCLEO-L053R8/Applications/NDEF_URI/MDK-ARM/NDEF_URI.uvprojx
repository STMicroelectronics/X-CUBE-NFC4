# Keil uVision project NDEF_URI.uvprojx, settings and files
target NDEF_URI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: NDEF_URI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../NFC/App;../NFC/Target;../Core/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/ST25DV;../../../../../Drivers/BSP/NFC04A1;../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/inc;../../../../../Middlewares/ST/lib_nfc/Common/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_nucleo_bus.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/User/NFC/App
    ../NFC/App/: app_nfc.c
  group Application/User/NFC/Target
    ../NFC/Target/: lib_NDEF_config.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/BSP/NFC04A1
    ../../../../../Drivers/BSP/NFC04A1/: nfc04a1.c nfc04a1_nfctag.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Middlewares/lib_nfc/Wireless/lib_nfc/Core
    ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
software components: CMSIS:CORE 4.3.0
