# IAR project NDEF_URI.ewp, settings and files
configuration NDEF_URI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../NFC/App; ../NFC/Target; ../Core/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/ST25DV; ../../../../../Drivers/BSP/NFC04A1; ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/inc; ../../../../../Middlewares/ST/lib_nfc/Common/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\..\Binary\NDEF_URI.bin
  ILINK.IlinkOutputFile: NDEF_URI.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_nucleo_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/NFC/App
    ../NFC/App/: app_nfc.c
  group Application/User/NFC/Target
    ../NFC/Target/: lib_NDEF_config.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/BSP/NFC04A1
    ../../../../../Drivers/BSP/NFC04A1/: nfc04a1.c nfc04a1_nfctag.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Middlewares/lib_nfc/Wireless/lib_nfc/Core
    ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
